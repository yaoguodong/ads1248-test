# Keil uVision project ads1248.uvprojx, settings and files
target ads1248 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32L151RE STMicroelectronics
  pack: Keil.STM32L1xx_DFP.1.0.2
  cpu: IRAM(0x20000000,0x14000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: ads1248
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER STM32L1XX_HD
  c include: .\src inh;.\Libraries\STM32L1xx_StdPeriph_Driver\inc;.\Libraries\CMSIS\Device\ST\STM32L1xx\Include
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x14000
  group user
    ./src inh/: main.c ads1248.c delay.c
  group New Group
    ./Libraries/STM32L1xx_StdPeriph_Driver/src/: stm32l1xx_gpio.c stm32l1xx_spi.c stm32l1xx_pwr.c stm32l1xx_rcc.c
software components: CMSIS:CORE 5.0.2, Device:Startup 1.0.0
